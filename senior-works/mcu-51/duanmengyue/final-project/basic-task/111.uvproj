# Keil uVision project 111.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 111 +hex
  c flags: Optimize=9
  group Source Group 1
    ./: 111.c EEPROM.c
