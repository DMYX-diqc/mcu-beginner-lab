/*********************************************************************************************************
* 模块名称: App.c
* 摘    要: 测试队列
* 当前版本: 1.0.0
* 作    者: Leyutek(COPYRIGHT 2018 - 2021 Leyutek. All rights reserved.)
* 完成日期: 2021年03月01日   
* 内    容:
* 注    意:                                                                   
**********************************************************************************************************
* 取代版本: 
* 作    者:
* 完成日期: 
* 修改内容:
* 修改文件: 
*********************************************************************************************************/

/*********************************************************************************************************
*                                              包含头文件
*********************************************************************************************************/
#include <stdio.h>
#include <stdlib.h> 
#include "Queue.h"

/*********************************************************************************************************
*                                              宏定义
*********************************************************************************************************/

/*********************************************************************************************************
*                                              枚举结构体定义
*********************************************************************************************************/

/*********************************************************************************************************
*                                              内部变量
*********************************************************************************************************/

/*********************************************************************************************************
*                                              内部函数声明
*********************************************************************************************************/

/*********************************************************************************************************
*                                              内部函数实现
*********************************************************************************************************/

/*********************************************************************************************************
*                                              API函数实现
*********************************************************************************************************/

/*********************************************************************************************************
* 函数名称: main
* 函数功能: 主函数 
* 输入参数: void
* 输出参数: void
* 返 回 值: void
* 创建日期: 2021年03月01日
* 注    意: 该函数的主要目的是测试循环队列是否正确
*********************************************************************************************************/
void main(void)
{
  StructCirQue    cirQueForTest;        //循环队列中
  DATA_TYPE i;
  DATA_TYPE bufForTest[30];             //循环队列中的buffer，可容纳30个元素

  i16       len;                        //长度

  DATA_TYPE arrBufForOutput[30];        //从队列取出的数据放入此数组
  DATA_TYPE arrBufForInput[60];         //入队的数据先放到此处
  DATA_TYPE dataForTest;                //便于printf调用

  for(i = 0; i < 60; i++)
  {
    arrBufForInput[i] = 60 + i * 2 + 1;
  }

  for(i = 0; i < 30; i++)
  {
    arrBufForOutput[i] = 0;
  }

  InitQueue(&cirQueForTest, bufForTest, 30);


  //入队16个数据
  printf("**************TEST1-入队16个数据******************\n"); 
  EnQueue(&cirQueForTest, arrBufForInput, 16); 

  for(i = 0; i < 30; i++)
  {
    dataForTest = cirQueForTest.pBuffer[i];
    printf("addr=%d, dataInput=%d\n", i, dataForTest);
  }

  //出队25个数据，实际只能出对16个数据
  printf("**************TEST2-出队25个数据，实际只能出对16个数据******************\n");
  len = DeQueue(&cirQueForTest, arrBufForOutput, 25);

  printf("Num of DeQueue: %d\n", len);

  for(i = 0; i < len; i++)
  {
    printf("i=%d, dataOuput=%d\n", i, arrBufForOutput[i]);
  }

  //入队20个数据
  printf("**************TEST3-入队20个数据******************\n");

  len = EnQueue(&cirQueForTest, &arrBufForInput[20], 20);
  
  printf("Num of EnQueue: %d\n", len);
  
  for(i = 0; i < 30; i++)
  {
    dataForTest = cirQueForTest.pBuffer[i];
    printf("addr=%d, dataInput=%d\n", i, dataForTest);
  }

  //出队20个数据
  printf("**************TEST4-出队20个数据******************\n");
  
  len = DeQueue(&cirQueForTest, arrBufForOutput, 20); 

  printf("Num of DeQueue: %d\n", len);

  for(i = 0; i < len; i++)
  {
    printf("i=%d, dataOuput=%d\n", i, arrBufForOutput[i]);
  }

  system("pause");
}